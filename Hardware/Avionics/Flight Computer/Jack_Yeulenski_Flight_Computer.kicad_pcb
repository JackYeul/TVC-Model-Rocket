# Repository JackYeul/TVC-Model-Rocket

File README.md:

# TVC-Model-Rocket
Repository for the simulation, design, and programming of a thrust vector controlled model rocket

## KiCad design Hardware/Avionics/Flight Computer/Jack_Yeulenski_Flight_Computer.kicad_pcb

Parts:
BZ1: Buzzer; Adafruit_Buzzer
C6: 0.01 uF; C_0805_2012Metric
C7: 22 uF; CAP_YX_5X11_RUB
C8: 22uF; CAP_YX_5X11_RUB
CR1: MBRS120T3G; SDO_MBRS120T3G_OSI
D1, D2, D3: LED; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: SW; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J2: BAT; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J3: SERVO_1; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
J4: I2C GPS Connector; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J5: SERVO_2; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
L1: 22 uH; IND_TAIYO_NRS8040_TAY
R1, R2, R3: 560; R_0603_1608Metric
R4: 100k; R_0603_1608Metric
R5: 78k7; R_0603_1608Metric
R6, R9: 10k; R_0603_1608Metric
R7: 1k; R_0603_1608Metric
R8: 3.3k; R_0603_1608Metric
R10: 300; R_0603_1608Metric
R11: 110; R_0603_1608Metric
R12: 280; R_0603_1608Metric
Rpull1, Rpull2: 5k1; R_0402_1005Metric
Teensy4.1: teensy
U2: NCV5171EDR2G; SOIC-8_NB_ONS

Connections:
+3.3V: D3.2 (A), J4.1, Teensy4.1.3V (3.3V)
+3V3: Rpull1.2, Rpull2.2, Teensy4.1.3V1 (3.3V); also elsewhere on the board
+5V: C7.1, CR1.1, R11.1
+5V_SERVO: J3.2 (+5V), J5.2 (+5V)
GND: BZ1.2 (-), C7.2, C8.2, J2.2, J3.3 (GND), J4.4, J5.3 (GND), R1.2, R2.2, R3.2, R4.1, R6.1, R7.1, R9.1, Teensy4.1.G (GND), Teensy4.1.G1 (GND), Teensy4.1.G2 (GND), U2.6 (AGND), U2.7 (PGND); also elsewhere on the board
unnamed: BZ1.1 (+), Teensy4.1.33 (PWM)
unnamed: C6.2, R6.2, R9.2
unnamed: D1.2 (A), Teensy4.1.31 (GPIO)
unnamed: D1.1 (K), R1.1
unnamed: D2.2 (A), Teensy4.1.32 (GPIO)
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: C8.1, J1.1, L1.1, Teensy4.1.5V (VIN), U2.5 (VCC)
unnamed: J1.2, J2.1, R5.2
unnamed: R10.1, R11.2
unnamed: R8.2, R10.2
unnamed: R7.2, R12.1
unnamed: R4.2, R5.1, Teensy4.1.14 (A0)
unnamed: R8.1, R12.2, U2.2 (FB)
unnamed: C6.1, U2.1 (VC)
unnamed: CR1.2, L1.2, U2.8 (VSW)
RX: Teensy4.1.0 (RX1)
SCL: Rpull1.1, Teensy4.1.19 (SCL); also elsewhere on the board
SCL2: J4.3, Teensy4.1.24 (SCL2)
SDA: Rpull2.1, Teensy4.1.18 (SDA); also elsewhere on the board
SDA2: J4.2, Teensy4.1.25 (SDA2)
SERVO1_PWM: J3.1 (SERVO_PWM), Teensy4.1.2 (PWM)
SERVO2_PWM: J5.1 (SERVO_PWM), Teensy4.1.3 (PWM)
TX: Teensy4.1.1 (TX1)

Notes on the sheet:
Voltage divider info: Ratio Vin/Vo = 1.79 5.5Vin = 3.07Vo
3.71kO ~= 3.72kO
5 kO parallel equivalent
1.28kO
check footprints/actual products on polarized caps

Parts:
C9: 100nF
U4: MS5611-01BA; LGA-8_3x5mm_P1.25mm

Connections:
+3V3: C9.1, U4.1 (VDD), U4.2 (PS), U4.4 (CSB), U4.5 (CSB); also elsewhere on the board
GND: C9.2, U4.3 (GND); also elsewhere on the board
SCL: U4.8 (SCLK); also elsewhere on the board
SDA: U4.7 (SDI/SDA); also elsewhere on the board

Notes on the sheet:
7Bit I2C address of MS5611 is 0x76 = 1110110 with CSB connected to VDD, 0x77 = 1110111 if connected to GND

Parts:
C10, C11: 100nF; C_0805_2012Metric
U3: BMI088; Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNu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

Connections:
+3V3: C10.1, C11.1, U3.3 (VDD), U3.7 (PS), U3.11 (VDDIO), U3.14 (~CSB1); also elsewhere on the board
GND: C10.2, C11.2, U3.2 (GNDA), U3.4 (GNDA), U3.6 (GNDIO), U3.10 (SDO2), U3.15 (SDO1); also elsewhere on the board
SCL: U3.8 (SCK/SCL); also elsewhere on the board
SDA: U3.9 (SDI/SDA); also elsewhere on the board

Notes on the sheet:
Default I2C address (SDO1 LOW): 0011000b (0x18) Alternate I2C address (SDO1 HIGH): 0011001b (0x19) SDO1 is used to switch adresss of Accelerometer Gyro: Default I2C address (SDO2 LOW): 1101000b (0x68) Alternate I2C address (SDO2 HIGH): 1101001b (0x69) SDO2 is used to switch adresss of Gyroscope
Should be done, went through all pins on datasheet

Board: 2 copper layers, 57.4 x 65.5 mm, 38 parts (0 on the bottom side), 27 nets.
